Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_6/temp/tmp_304_70_iAHZg/format_1/375600010001(300).ifc
Time: 2023-09-27T14:11:28
Made in: PARTsolutions

# IfcProject, 375600010001(300)
Description: CAYONOPLAN

# IfcDiscreteAccessory, 375600010001(300)
In: BUILDING
Description: 375600010001(300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 375600010001
ePset_PARTsolutions - NB: 375600010001(300); NN: 2226; NT: CAYONOPLAN; NBSYN: $A.($LODLEVEL.); LINA: 375600010001(300); CATALOG: Kaldewei; A: 375600010001; LODLEVEL: 300; B: 2262_r18_1_0_0_0_0_0_0_0_0_0_0_0.png; C: CAYONOPLAN Mod. 2226; D: 38.2; E: KALDEWEI; F: 4055761318082; M: -; N: -; O: -; P: -; Q: -; R: -; S: EC011443; EF002169: enamelled steel (EV000166); EF000139: Enamelled (EV002029); EF000051: rectangular (EV000220); EF000007: alpine white (EV000202); EF000049: 1600; EF004567: 900; EF000040: 32
